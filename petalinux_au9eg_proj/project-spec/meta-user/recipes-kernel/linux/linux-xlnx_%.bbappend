FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://user_2025-08-19-01-16-00.cfg \
            file://user_2025-08-20-00-15-00.cfg \
            file://user_2025-08-20-00-24-00.cfg \
            "

